/*
 * Copyright (C) 2026 wolfSSL Inc.
 *
 * This file is part of wolfCert.
 *
 * wolfCert is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation; either version 3 of the License, or
 * (at your option) any later version.
 *
 * wolfCert is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with wolfCert.  If not, see <http://www.gnu.org/licenses/>.
 */

#include <wolfcert/wolfcert.h>
#include "internal.h"
#include "../test_static_mem.h"

#include <wolfssl/wolfcrypt/cryptocb.h>
#include <wolfssl/wolfcrypt/error-crypt.h>

#include <stdio.h>
#include <string.h>

#if defined(WOLFCERT_HAVE_ECC)
    #define TEST_KEY_TYPE  WOLFCERT_KEY_ECC
    #define TEST_KEY_PARAM 256
#elif defined(WOLFCERT_HAVE_RSA)
    #define TEST_KEY_TYPE  WOLFCERT_KEY_RSA
    #define TEST_KEY_PARAM 2048
#elif defined(WOLFCERT_HAVE_MLDSA) && !defined(WOLFSSL_NO_ML_DSA_65)
    #define TEST_KEY_TYPE  WOLFCERT_KEY_MLDSA65
    #define TEST_KEY_PARAM 0
#endif

#define REQUIRE(cond) \
    do {                                                                    \
        if (!(cond)) {                                                      \
            fprintf(stderr, "FAIL %s:%d %s\n", __FILE__, __LINE__, #cond);  \
            return 1;                                                       \
        }                                                                   \
    } while (0)

static int roundtrip(WolfCertKeyType type, int param)
{
    WolfCertKeyCfg cfg = { .type = type, .param = param,
                           .dev_id = WOLFCERT_DEVID_SOFTWARE };
    WolfCertKey* k = NULL;
    REQUIRE(wolfcert_key_generate(&cfg, &k) == WOLFCERT_OK);
    REQUIRE(k != NULL);

    WolfCertBuffer pem = { 0 };
    REQUIRE(wolfcert_key_to_pem(k, &pem) == WOLFCERT_OK);
    REQUIRE(pem.len > 0);
    REQUIRE(memchr(pem.data, '-', pem.len) != NULL);

    WolfCertKey* k2 = NULL;
    REQUIRE(wolfcert_key_from_pem(pem.data, pem.len, NULL, &k2) == WOLFCERT_OK);
    REQUIRE(k2 != NULL);

    /* Re-import the key from its DER export; 0x30 is the SEQUENCE tag. */
    WolfCertBuffer der = { 0 };
    REQUIRE(wolfcert_key_to_der(k, &der) == WOLFCERT_OK);
    REQUIRE(der.len > 0);
    REQUIRE(der.data[0] == 0x30);

    WolfCertKey* k3 = NULL;
    REQUIRE(wolfcert_key_from_pem(der.data, der.len, NULL, &k3) == WOLFCERT_OK);
    REQUIRE(k3 != NULL);

    const uint8_t* id = (const uint8_t*)"x";
    size_t id_len = 1;
    REQUIRE(wolfcert_key_id(k, &id, &id_len) == WOLFCERT_OK);
    REQUIRE(id == NULL && id_len == 0);

    wolfcert_buffer_free(&pem);
    wolfcert_buffer_free(&der);
    wolfcert_key_free(k);
    wolfcert_key_free(k2);
    wolfcert_key_free(k3);
    return 0;
}

#ifdef TEST_KEY_TYPE
#define DECLINE_DEVID 0x6b69

#if defined(WOLF_CRYPTO_CB) && defined(WOLF_PRIVATE_KEY_ID)
static int decline_cb(int devId, wc_CryptoInfo* info, void* ctx)
{
    (void)devId;
    (void)info;
    (void)ctx;
    return CRYPTOCB_UNAVAILABLE;
}

/* A device that declines keygen leaves wolfCrypt to generate in software,
 * which a key_id must refuse. */
static int key_id_declined(WolfCertKeyType type, int param)
{
    static const uint8_t id[] = { 0x01, 0x02 };
    WolfCertKeyCfg cfg = { .type = type, .param = param,
                           .dev_id = DECLINE_DEVID,
                           .key_id = id, .key_id_len = sizeof(id) };
    WolfCertKey* k = NULL;

    REQUIRE(wolfcert_key_generate(&cfg, &k) == WOLFCERT_ERR_UNSUPPORTED);
    REQUIRE(k == NULL);
    return 0;
}

static int key_id_cases(void)
{
    static const uint8_t id[] = { 0x01, 0x02 };
    static const uint8_t junk[] = { 0x30, 0x03, 0x02, 0x01, 0x00 };
    WolfCertKey* k = NULL;

    REQUIRE(wc_CryptoCb_RegisterDevice(DECLINE_DEVID, decline_cb, NULL) == 0);
    WolfCertKeyCfg cfg = { .type = TEST_KEY_TYPE, .param = TEST_KEY_PARAM,
                           .dev_id = INVALID_DEVID,
                           .key_id = id, .key_id_len = sizeof(id) };
    REQUIRE(wolfcert_key_generate(&cfg, &k) == WOLFCERT_ERR_BAD_ARG);
    cfg.dev_id = DECLINE_DEVID;
    cfg.key_id_len = 0;
    REQUIRE(wolfcert_key_generate(&cfg, &k) == WOLFCERT_ERR_BAD_ARG);
    REQUIRE(strstr(wolfcert_last_error_message(), "key_id_len") != NULL);
    cfg.dev_id = INVALID_DEVID;
    cfg.key_id_len = sizeof(id);

    if (key_id_declined(TEST_KEY_TYPE, TEST_KEY_PARAM))
        return 1;
#ifdef WOLFCERT_HAVE_RSA
    if (key_id_declined(WOLFCERT_KEY_RSA, 2048))
        return 1;
#endif
#ifdef WOLFCERT_HAVE_MLDSA
#ifndef WOLFSSL_NO_ML_DSA_44
    if (key_id_declined(WOLFCERT_KEY_MLDSA44, 0))
        return 1;
#endif
#ifndef WOLFSSL_NO_ML_DSA_65
    if (key_id_declined(WOLFCERT_KEY_MLDSA65, 0))
        return 1;
#endif
#ifndef WOLFSSL_NO_ML_DSA_87
    if (key_id_declined(WOLFCERT_KEY_MLDSA87, 0))
        return 1;
#endif
#endif
#if defined(WOLFCERT_HAVE_ED25519) && defined(ED25519_MAX_ID_LEN)
    if (key_id_declined(WOLFCERT_KEY_ED25519, 0))
        return 1;
#endif

    cfg.dev_id = DECLINE_DEVID;
    cfg.key_id_len = 0;
    REQUIRE(wolfcert_key_from_id(&cfg, junk, sizeof(junk), &k) ==
            WOLFCERT_ERR_BAD_ARG);
    k = (WolfCertKey*)&cfg;
    REQUIRE(wolfcert_key_from_id(&cfg, NULL, 0, &k) == WOLFCERT_ERR_BAD_ARG);
    REQUIRE(k == NULL);
    cfg.key_id_len = sizeof(id);
    REQUIRE(wolfcert_key_from_id(&cfg, junk, sizeof(junk), &k) ==
            WOLFCERT_ERR_PARSE);
#ifdef WOLFCERT_HAVE_RSA
    /* Even with param 0, a reload refuses an RSA size keygen would not make. */
    {
        static const uint8_t weak[] = {
            0x30, 0x82, 0x01, 0xf7, 0x30, 0x82, 0x01, 0x60, 0xa0, 0x03, 0x02,
            0x01, 0x02, 0x02, 0x14, 0x59, 0x46, 0x07, 0x05, 0xaa, 0x88, 0x4f,
            0xba, 0x81, 0x5e, 0xee, 0x36, 0x6e, 0xf3, 0x66, 0xd2, 0x9f, 0x0d,
            0x68, 0x8f, 0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7,
            0x0d, 0x01, 0x01, 0x0b, 0x05, 0x00, 0x30, 0x0f, 0x31, 0x0d, 0x30,
            0x0b, 0x06, 0x03, 0x55, 0x04, 0x03, 0x0c, 0x04, 0x77, 0x65, 0x61,
            0x6b, 0x30, 0x1e, 0x17, 0x0d, 0x32, 0x36, 0x31, 0x30, 0x31, 0x37,
            0x31, 0x32, 0x31, 0x36, 0x31, 0x39, 0x5a, 0x17, 0x0d, 0x33, 0x36,
            0x31, 0x30, 0x31, 0x34, 0x31, 0x32, 0x31, 0x36, 0x31, 0x39, 0x5a,
            0x30, 0x0f, 0x31, 0x0d, 0x30, 0x0b, 0x06, 0x03, 0x55, 0x04, 0x03,
            0x0c, 0x04, 0x77, 0x65, 0x61, 0x6b, 0x30, 0x81, 0x9f, 0x30, 0x0d,
            0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x01,
            0x05, 0x00, 0x03, 0x81, 0x8d, 0x00, 0x30, 0x81, 0x89, 0x02, 0x81,
            0x81, 0x00, 0xd6, 0x71, 0xd3, 0xa4, 0x94, 0x12, 0x9e, 0x33, 0x9c,
            0x3e, 0x4c, 0x0f, 0xd0, 0xe1, 0x90, 0xd0, 0x25, 0x95, 0x19, 0x34,
            0x96, 0x6e, 0x97, 0x0b, 0x48, 0x21, 0x0f, 0x26, 0xb4, 0x03, 0x92,
            0xb6, 0x99, 0xe7, 0xe7, 0x7a, 0xe5, 0x73, 0x8d, 0x37, 0x54, 0xf9,
            0x8c, 0xe0, 0x1d, 0x0e, 0xae, 0x63, 0x80, 0x72, 0x4a, 0xb9, 0x94,
            0xef, 0x82, 0x30, 0x70, 0xda, 0xce, 0x85, 0x52, 0x0b, 0x75, 0x18,
            0xb9, 0x4d, 0xcb, 0xc0, 0x30, 0x69, 0x06, 0xcb, 0x9d, 0x03, 0x5c,
            0xe0, 0x6c, 0xf9, 0xe8, 0x6d, 0x08, 0xe8, 0xb2, 0xb7, 0x60, 0x31,
            0xc3, 0xfc, 0x2c, 0x01, 0xb7, 0xaf, 0x10, 0xaa, 0xe2, 0x89, 0xcb,
            0xad, 0xa9, 0xa0, 0xcf, 0x68, 0x8e, 0xa6, 0x36, 0xcd, 0xdc, 0x16,
            0xc8, 0x59, 0xad, 0x38, 0x5e, 0xc1, 0x9f, 0xdb, 0xa4, 0x6a, 0xa6,
            0x43, 0x2d, 0x94, 0xe1, 0xcf, 0xd2, 0x71, 0x59, 0x93, 0x02, 0x03,
            0x01, 0x00, 0x01, 0xa3, 0x50, 0x30, 0x4e, 0x30, 0x1d, 0x06, 0x03,
            0x55, 0x1d, 0x0e, 0x04, 0x16, 0x04, 0x14, 0xa8, 0xc9, 0xf0, 0x7b,
            0x4e, 0x72, 0x2d, 0x7a, 0xb7, 0x51, 0x48, 0x2d, 0x6e, 0x34, 0x92,
            0xc9, 0x10, 0x74, 0x3c, 0x9b, 0x30, 0x1f, 0x06, 0x03, 0x55, 0x1d,
            0x23, 0x04, 0x18, 0x30, 0x16, 0x80, 0x14, 0xa8, 0xc9, 0xf0, 0x7b,
            0x4e, 0x72, 0x2d, 0x7a, 0xb7, 0x51, 0x48, 0x2d, 0x6e, 0x34, 0x92,
            0xc9, 0x10, 0x74, 0x3c, 0x9b, 0x30, 0x0c, 0x06, 0x03, 0x55, 0x1d,
            0x13, 0x01, 0x01, 0xff, 0x04, 0x02, 0x30, 0x00, 0x30, 0x0d, 0x06,
            0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x0b, 0x05,
            0x00, 0x03, 0x81, 0x81, 0x00, 0x34, 0xaa, 0x11, 0x9e, 0x41, 0x4a,
            0x5e, 0x86, 0x2e, 0xae, 0x14, 0x37, 0xf8, 0xfa, 0x0b, 0x05, 0x5b,
            0x46, 0x31, 0x08, 0xef, 0xae, 0x6d, 0xd2, 0x23, 0xc0, 0xb6, 0xb8,
            0xb7, 0x63, 0x68, 0x26, 0x33, 0x04, 0x72, 0xab, 0x98, 0x4a, 0xb8,
            0xad, 0x86, 0xef, 0xc3, 0xdf, 0x5a, 0x7b, 0x00, 0x87, 0x8e, 0xf2,
            0x8f, 0x97, 0x19, 0x62, 0x4b, 0xda, 0x36, 0xdc, 0x31, 0x79, 0xf9,
            0x45, 0x1d, 0x7d, 0xbe, 0xc7, 0x51, 0xff, 0xd2, 0xd6, 0x73, 0xd3,
            0x88, 0x0b, 0x54, 0x6c, 0x2f, 0xb9, 0xe1, 0x08, 0xe9, 0x0e, 0x4e,
            0xe8, 0xba, 0x9c, 0x04, 0x74, 0x37, 0x6f, 0x49, 0x73, 0x1d, 0x21,
            0x02, 0xa7, 0x67, 0x11, 0x1a, 0x85, 0x01, 0x88, 0x2a, 0x40, 0x32,
            0x6f, 0x12, 0x3c, 0x68, 0xa9, 0xe6, 0x40, 0x4e, 0xa2, 0x4a, 0x8a,
            0x2f, 0xed, 0x8d, 0x8e, 0xac, 0xbc, 0xee, 0xf3, 0x1f, 0xe8, 0x54,
            0x97,
        };
        WolfCertKeyCfg rcfg = { .type = WOLFCERT_KEY_RSA,
                                .dev_id = DECLINE_DEVID,
                                .key_id = id, .key_id_len = sizeof(id) };

        REQUIRE(wolfcert_key_from_id(&rcfg, weak, sizeof(weak), &k) ==
                WOLFCERT_ERR_UNSUPPORTED);
#ifdef WOLFCERT_HAVE_ECC
        rcfg.type = WOLFCERT_KEY_ECC;
        REQUIRE(wolfcert_key_from_id(&rcfg, weak, sizeof(weak), &k) ==
                WOLFCERT_ERR_PARSE);
        REQUIRE(strstr(wolfcert_last_error_message(), "not a type") != NULL);
#endif
    }
#endif
#ifdef WOLFCERT_HAVE_ECC
    /* Likewise a curve keygen does not make: a P-224 certificate. */
    {
        static const uint8_t p224[] = {
            0x30, 0x82, 0x01, 0x5f, 0x30, 0x82, 0x01, 0x0e, 0xa0, 0x03, 0x02,
            0x01, 0x02, 0x02, 0x14, 0x3d, 0xf5, 0x24, 0x44, 0x39, 0x0d, 0xf6,
            0x77, 0xeb, 0xd4, 0x87, 0x95, 0x79, 0x98, 0xc5, 0xd2, 0x06, 0xb7,
            0xdb, 0x94, 0x30, 0x0a, 0x06, 0x08, 0x2a, 0x86, 0x48, 0xce, 0x3d,
            0x04, 0x03, 0x02, 0x30, 0x0f, 0x31, 0x0d, 0x30, 0x0b, 0x06, 0x03,
            0x55, 0x04, 0x03, 0x0c, 0x04, 0x70, 0x32, 0x32, 0x34, 0x30, 0x1e,
            0x17, 0x0d, 0x32, 0x36, 0x31, 0x30, 0x31, 0x37, 0x31, 0x34, 0x30,
            0x36, 0x33, 0x32, 0x5a, 0x17, 0x0d, 0x33, 0x36, 0x31, 0x30, 0x31,
            0x34, 0x31, 0x34, 0x30, 0x36, 0x33, 0x32, 0x5a, 0x30, 0x0f, 0x31,
            0x0d, 0x30, 0x0b, 0x06, 0x03, 0x55, 0x04, 0x03, 0x0c, 0x04, 0x70,
            0x32, 0x32, 0x34, 0x30, 0x4e, 0x30, 0x10, 0x06, 0x07, 0x2a, 0x86,
            0x48, 0xce, 0x3d, 0x02, 0x01, 0x06, 0x05, 0x2b, 0x81, 0x04, 0x00,
            0x21, 0x03, 0x3a, 0x00, 0x04, 0xe8, 0x66, 0x0e, 0x19, 0x35, 0xc9,
            0x09, 0x98, 0xb2, 0x14, 0x18, 0x2a, 0xb8, 0x7b, 0x4e, 0x2b, 0x89,
            0xea, 0x78, 0x54, 0x01, 0xc4, 0x25, 0xb2, 0x10, 0x52, 0xed, 0x26,
            0x22, 0x4a, 0x23, 0x42, 0x6e, 0x2d, 0x9f, 0x50, 0x37, 0xfc, 0xf4,
            0x2a, 0x94, 0x43, 0xf1, 0x28, 0xee, 0x44, 0xff, 0x6f, 0x92, 0xa7,
            0xab, 0xb5, 0xdb, 0x52, 0x36, 0x26, 0xa3, 0x53, 0x30, 0x51, 0x30,
            0x1d, 0x06, 0x03, 0x55, 0x1d, 0x0e, 0x04, 0x16, 0x04, 0x14, 0x03,
            0x45, 0x74, 0x20, 0xc9, 0xc6, 0xc6, 0xdd, 0x0f, 0xe5, 0x17, 0xbf,
            0x61, 0xe3, 0xbc, 0x21, 0xce, 0x0a, 0x31, 0xc8, 0x30, 0x1f, 0x06,
            0x03, 0x55, 0x1d, 0x23, 0x04, 0x18, 0x30, 0x16, 0x80, 0x14, 0x03,
            0x45, 0x74, 0x20, 0xc9, 0xc6, 0xc6, 0xdd, 0x0f, 0xe5, 0x17, 0xbf,
            0x61, 0xe3, 0xbc, 0x21, 0xce, 0x0a, 0x31, 0xc8, 0x30, 0x0f, 0x06,
            0x03, 0x55, 0x1d, 0x13, 0x01, 0x01, 0xff, 0x04, 0x05, 0x30, 0x03,
            0x01, 0x01, 0xff, 0x30, 0x0a, 0x06, 0x08, 0x2a, 0x86, 0x48, 0xce,
            0x3d, 0x04, 0x03, 0x02, 0x03, 0x3f, 0x00, 0x30, 0x3c, 0x02, 0x1c,
            0x51, 0xad, 0x29, 0x59, 0x0b, 0x12, 0x22, 0x51, 0x76, 0x60, 0x02,
            0x26, 0x53, 0xb6, 0xd8, 0x46, 0xa8, 0xda, 0x06, 0x60, 0x6e, 0x67,
            0x4e, 0x71, 0xbe, 0x1c, 0xb0, 0x36, 0x02, 0x1c, 0x0c, 0x7b, 0x06,
            0x77, 0xf6, 0x9a, 0xed, 0xc0, 0x31, 0x92, 0x8c, 0x5e, 0x84, 0xb3,
            0x6f, 0xb1, 0x65, 0x2a, 0xe4, 0x4a, 0x89, 0x65, 0x3e, 0x16, 0x3f,
            0xb8, 0x05, 0x99,
        };
        WolfCertKeyCfg ecfg = { .type = WOLFCERT_KEY_ECC,
                                .dev_id = DECLINE_DEVID,
                                .key_id = id, .key_id_len = sizeof(id) };
        int erc = wolfcert_key_from_id(&ecfg, p224, sizeof(p224), &k);

#if (defined(HAVE_ECC224) || defined(HAVE_ALL_CURVES)) && ECC_MIN_KEY_SZ <= 224
        REQUIRE(erc == WOLFCERT_ERR_UNSUPPORTED);
#else
        REQUIRE(erc == WOLFCERT_ERR_PARSE);
#endif
    }
#endif
#if defined(WOLFCERT_HAVE_ED25519) && !defined(ED25519_MAX_ID_LEN)
    cfg.type = WOLFCERT_KEY_ED25519;
    cfg.param = 0;
    REQUIRE(wolfcert_key_from_id(&cfg, junk, sizeof(junk), &k) ==
            WOLFCERT_ERR_UNSUPPORTED);
#endif
    REQUIRE(k == NULL);

    wc_CryptoCb_UnRegisterDevice(DECLINE_DEVID);
    return 0;
}
#else
static int key_id_cases(void)
{
    static const uint8_t id[] = { 0x01, 0x02 };
    static const uint8_t junk[] = { 0x30, 0x03, 0x02, 0x01, 0x00 };
    WolfCertKeyCfg cfg = { .type = TEST_KEY_TYPE, .param = TEST_KEY_PARAM,
                           .dev_id = DECLINE_DEVID,
                           .key_id = id, .key_id_len = sizeof(id) };
    WolfCertKey* k = NULL;

    REQUIRE(wolfcert_key_generate(&cfg, &k) == WOLFCERT_ERR_UNSUPPORTED);
    REQUIRE(wolfcert_key_from_id(&cfg, junk, sizeof(junk), &k) ==
            WOLFCERT_ERR_UNSUPPORTED);
    REQUIRE(k == NULL);
    return 0;
}
#endif
#endif /* TEST_KEY_TYPE */

int main(void)
{
    REQUIRE(test_static_mem_init() == 0);
    REQUIRE(wolfcert_init(test_heap_hint()) == WOLFCERT_OK);
#ifdef WOLFCERT_HAVE_ECC
    if (roundtrip(WOLFCERT_KEY_ECC, 256))
        return 1;
    if (roundtrip(WOLFCERT_KEY_ECC, 384))
        return 1;
#endif
#ifdef WOLFCERT_HAVE_RSA
    if (roundtrip(WOLFCERT_KEY_RSA, 2048))
        return 1;
#endif
#ifdef WOLFCERT_HAVE_ED25519
    if (roundtrip(WOLFCERT_KEY_ED25519, 0))
        return 1;
#endif
#ifdef WOLFCERT_HAVE_ED448
    if (roundtrip(WOLFCERT_KEY_ED448, 0))
        return 1;
#endif
#ifdef WOLFCERT_HAVE_MLDSA
#ifndef WOLFSSL_NO_ML_DSA_44
    if (roundtrip(WOLFCERT_KEY_MLDSA44, 0))
        return 1;
#endif
#ifndef WOLFSSL_NO_ML_DSA_65
    if (roundtrip(WOLFCERT_KEY_MLDSA65, 0))
        return 1;
#endif
#ifndef WOLFSSL_NO_ML_DSA_87
    if (roundtrip(WOLFCERT_KEY_MLDSA87, 0))
        return 1;
#endif
#else
    /* Runtime rejection when the wolfSSL build lacks Dilithium. */
    {
        WolfCertKeyCfg cfg = { .type = WOLFCERT_KEY_MLDSA44, .param = 0,
                               .dev_id = WOLFCERT_DEVID_SOFTWARE };
        WolfCertKey* k = NULL;
        REQUIRE(wolfcert_key_generate(&cfg, &k) == WOLFCERT_ERR_UNSUPPORTED);
    }
#endif

#ifdef TEST_KEY_TYPE
    if (key_id_cases())
        return 1;
#endif

    WolfCertKeyCfg bad = { .type = WOLFCERT_KEY_ECC, .param = 123,
                           .dev_id = WOLFCERT_DEVID_SOFTWARE };
    WolfCertKey* k = NULL;
    REQUIRE(wolfcert_key_generate(&bad, &k) != WOLFCERT_OK);

    wolfcert_cleanup();
    printf("OK\n");
    return 0;
}
